1 ; TERMINAL.BAS
2 ; copyright T.Kamperman
3 ;
4   	ORG 7F9AH 	; start is 32666
5  KEYIN:	LD E,6 	; stream #6
6   	RST 20H
7   	DEFB 36H 	; STOP key
8   	JP C, STOP
9   	RST 20H
10   	DEFB 31H 	; input byte
11   	CP 0
12   	JP Z, RSTAT 	; no byte entered
13   	LD B, A 	; store byte in B
14 WSTAT:	LD E, 42H 	; stream #66
15   	RST 20H
16   	DEFB 31H 	; read write status
17   	BIT 2, A 	; check bit 2
18   	JP Z, WSTAT 	; wait for bit = 1
19 TRANS:	LD E, 40H 	; stream #64
20   	LD A, B 	; get byte from B
21   	RST 20H
22   	DEFB 30H 	; TX byte
23 RSTAT:	LD E, 42H 	; stream #66
24   	LD A, 10H 	; A = 16
25   	RST 20H
26   	DEFB 30H 	; set CTS
27   	LD A, 0
28   	RST 20H
29   	DEFB 30H 	; select reg 0
30   	RST 20H
31   	DEFB 31H 	; read dart status
32   	BIT 0, A 	; check bit 0
33   	JP Z, KEYIN 	; no byte received
34 READ:	LD E, 40H 	; stream #64
35   	RST 20H
36   	DEFB 31H 	; read RX byte
37 DISP:	LD E, 0 	; stream #0
38   	RST 20H
39   	DEFB 30H 	; input to screen
40   	LD A, 6
41   	RST 20H
42   	DEFB 30H 	; cursor on
43   	JP KEYIN
44 STOP:	RET 		; return to BASIC
