1 ; wijziging van TERMINAL.ZSM door Wim Luijt
2 
3 KEYIN:  XOR A           ; maak A=0 en reset carry
4         RST 20H
5         DEFB 36H        ; STOP key
6         RET C           ; terug naar BASIC
7         RST 20H
8         DEFB 31H        ; IMMKEY = slechts 15 bytes
9         JR C, RSTAT     ; no byte entered
10 ;
11 ; mogelijkheid bestaat om de keyboard coordinaten i.p.v. ASCII
12 ; in een eigen codering om te zetten, RST 20H + DEFB 3AH vervangen
13 ; door een CALL naar een vertaal routine/tabel, vb. franse usergroup
14 ;
15         RST 20H
16         DEFB 3AH        ; KLOOK
17         LD B, A         ; store byte in B
18 WSTAT:  LD E, 42H       ; stream #66
19         RST 20H
20         DEFB 31H        ; read write status
21         BIT 2, A        ; check bit 2
22         JR Z, WSTAT     ; wait for bit = 1
23 TRANS:  LD E, 40H       ; stream #64
24         LD A, B         ; get byte from B
25         RST 20H
26         DEFB 30H        ; TX byte
27 RSTAT:  LD E, 42H       ; stream #66
28         LD A, 10H       ; A = 16
29         RST 20H
30         DEFB 30H        ; set CTS
31         LD A, 0
32         RST 20H
33         DEFB 30H        ; select reg 0
34         RST 20H
35         DEFB 31H        ; read dart status
36         BIT 0, A        ; check bit 0
37         JR Z, KEYIN     ; no byte received
38 READ:   LD E, 40H       ; stream #64
39         RST 20H
40         DEFB 31H        ; read RX byte
41 DISP:   LD E, 0         ; stream #0
42         RST 20H
43         DEFB 30H        ; input to screen
44         JR KEYIN
45 
46 
47 
48 
